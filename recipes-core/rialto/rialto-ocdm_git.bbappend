require rialto_revision.inc

SRCREV = "${RIALTO_OCDM_VERSION}"
