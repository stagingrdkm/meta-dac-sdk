FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://sdl2-wayland-input-fix.patch"
SRC_URI += "file://eglgetdisplay-ldpreload-fix.patch"
